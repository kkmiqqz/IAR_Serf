# IAR project serf-all.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: E:\实验室Start\TrajectoryCompression\Serf_Embedded
  ICC8051.CCOptLevel: 2
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.IccLang: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group src/compressor
    src/compressor/: serf_qt_compressor.cc serf_qt_compressor.h
  group src/decompressor
    src/decompressor/: serf_qt_decompressor.cc serf_qt_decompressor.h
  group src/utils
    src/utils/: array.h double.h elias_gamma_codec.cc elias_gamma_codec.h file_reader.c file_reader.h input_bit_stream.cc input_bit_stream.h output_bit_stream.cc output_bit_stream.h zig_zag_codec.h
  group test/unit_test
    test/unit_test/: iar_serf_test.c

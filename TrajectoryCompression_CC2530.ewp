# IAR project TrajectoryCompression_CC2530.ewp, settings and files
configuration Debug ()
configuration Release ()
  as the first configuration, except:
  group Source Files
    test/unit_test/: iar_serf_test.c
    src/utils/: file_reader.c output_bit_stream.cc input_bit_stream.cc elias_gamma_codec.cc
    src/compressor/: serf_qt_compressor.cc
    src/decompressor/: serf_qt_decompressor.cc
    test/baselines/chimp128/: chimp_compressor.cc
  group Header Files
    src/utils/: array.h file_reader.h output_bit_stream.h input_bit_stream.h elias_gamma_codec.h zig_zag_codec.h double.h
    src/compressor/: serf_qt_compressor.h
    src/decompressor/: serf_qt_decompressor.h
    test/baselines/chimp128/: chimp_compressor.h
